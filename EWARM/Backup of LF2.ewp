# IAR project Backup of LF2.ewp, settings and files
configuration LF2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RB ST STM32F401RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xC
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LF2.srec
  ILINK.IlinkOutputFile: LF2.out
  ILINK.IlinkIcfFile: stm32f401xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xc.s
  group Application/User
    ../Src/: adc.c dma.c gpio.c i2c.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c
  group Application/User/eeprom_emulator
    ../Src/: eeprom_emulator.c
  group Application/User/motor
    ../Src/: motors.c
  group Application/User/PID
    ../Src/: PID.c
  group Application/User/sensors_misc
    ../Src/: sensors.c
  group Application/User/USART
    ../Src/: cQueue.c usart_tasks.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
